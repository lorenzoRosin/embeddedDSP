# IAR project LibEdsp.ewp, settings and files
configuration Library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Src; ..\..\Src\Alg\Inc; ..\..\Src\Alg\Src; ..\..\Src\Filter\Inc; ..\..\Src\Filter\Src; ..\..\Src\Math\Inc; ..\..\Src\Math\Src; ..\..\Src\Utils\Inc; ..\..\Src\Utils\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ../../Src/: eDSP_STANDARDTYPE.h eDSP_TYPE.h
  group Alg/Inc
    ../../Src/Alg/Inc/: eDSP_PID.h
  group Alg/Src
    ../../Src/Alg/Src/: eDSP_PID.c
  group Filter/Inc
    ../../Src/Filter/Inc/: eDSP_DECIMATORFILTER.h eDSP_HPASSFILTER.h eDSP_LPASSFILTER.h eDSP_MEANFILTER.h eDSP_MEDIANFILTER.h
  group Filter/Src
    ../../Src/Filter/Src/: eDSP_DECIMATORFILTER.c eDSP_HPASSFILTER.c eDSP_LPASSFILTER.c eDSP_MEANFILTER.c eDSP_MEDIANFILTER.c
  group Math/Inc
    ../../Src/Math/Inc/: eDSP_DERIVATIVE.h eDSP_INTEGRAL.h eDSP_M2DPI64LINEAR.h eDSP_S2DPI64LINEAR.h
  group Math/Src
    ../../Src/Math/Src/: eDSP_DERIVATIVE.c eDSP_INTEGRAL.c eDSP_M2DPI64LINEAR.c eDSP_S2DPI64LINEAR.c
  group Utils/Inc
    ../../Src/Utils/Inc/: eDSP_MAXCHECK.h
  group Utils/Src
    ../../Src/Utils/Src/: eDSP_MAXCHECK.c
