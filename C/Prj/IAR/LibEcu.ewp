# IAR project LibEcu.ewp, settings and files
configuration Library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Src; ..\..\Src\ByteStuffing\Inc; ..\..\Src\ByteStuffing\Src; ..\..\Src\Crc\Inc; ..\..\Src\Crc\Src; ..\..\Src\DataPacking\Inc; ..\..\Src\DataPacking\Src; ..\..\Src\Queue\Inc; ..\..\Src\Queue\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ../../Src/: eDSP_STANDARDTYPE.h eDSP_TYPE.h
  group ByteStuffing/Inc
    ../../Src/ByteStuffing/Inc/: eDSP_BSTF.h eDSP_BSTFPRV.h eDSP_BUNSTF.h eDSP_BUNSTFPRV.h
  group ByteStuffing/Src
    ../../Src/ByteStuffing/Src/: eDSP_BSTF.c eDSP_BUNSTF.c
  group Crc/Inc
    ../../Src/Crc/Inc/: eDSP_CRC.h eDSP_CRCD.h
  group Crc/Src
    ../../Src/Crc/Src/: eDSP_CRC.c eDSP_CRCD.c
  group DataPacking/Inc
    ../../Src/DataPacking/Inc/: eDSP_DPK.h eDSP_DUNPK.h
  group DataPacking/Src
    ../../Src/DataPacking/Src/: eDSP_DPK.c eDSP_DUNPK.c
  group Queue/Inc
    ../../Src/Queue/Inc/: eDSP_CIRQ.h
  group Queue/Src
    ../../Src/Queue/Src/: eDSP_CIRQ.c
