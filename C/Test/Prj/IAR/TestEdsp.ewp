# IAR project TestEdsp.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\Src; ..\..\..\Src\ByteStuffing\Inc; ..\..\..\Src\ByteStuffing\Src; ..\..\..\Src\Crc\Inc; ..\..\..\Src\Crc\Src; ..\..\..\Src\DataPacking\Inc; ..\..\..\Src\DataPacking\Src; ..\..\..\Src\Queue\Inc; ..\..\..\Src\Queue\Src; ..\..\Src\ByteStuffing\Inc; ..\..\Src\ByteStuffing\Src; ..\..\Src\Crc\Inc; ..\..\Src\Crc\Src; ..\..\Src\DataPacking\Inc; ..\..\Src\DataPacking\Src; ..\..\Src\Queue\Inc; ..\..\Src\Queue\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Src\TestFunction\Inc; ..\..\Src\TestFunction\Src
  OBJCOPY.OOCOutputFile: TestEdsp.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: ..\..\..\Prj\IAR\Library\Exe\LibEdsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group ByteStuffing/Inc
    ../../Src/ByteStuffing/Inc/: eDSP_BSTFBUNSTFTST.h eDSP_BSTFTST.h eDSP_BUSTFTST.h
  group ByteStuffing/Src
    ../../Src/ByteStuffing/Src/: eDSP_BSTFBUNSTFTST.c eDSP_BSTFTST.c eDSP_BUSTFTST.c
  group Crc/Inc
    ../../Src/Crc/Inc/: eDSP_CRCDTST.h eDSP_CRCTST.h
  group Crc/Src
    ../../Src/Crc/Src/: eDSP_CRCDTST.c eDSP_CRCTST.c
  group DataPacking/Inc
    ../../Src/DataPacking/Inc/: eDSP_DPKDUNPKTST.h eDSP_DPKTST.h eDSP_DUNPKTST.h
  group DataPacking/Src
    ../../Src/DataPacking/Src/: eDSP_DPKDUNPKTST.c eDSP_DPKTST.c eDSP_DUNPKTST.c
  group Queue/Inc
    ../../Src/Queue/Inc/: eDSP_CIRQTST.h
  group Queue/Src
    ../../Src/Queue/Src/: eDSP_CIRQTST.c
