<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\Prj\IAR\LibEdsp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TestEdsp.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>TEST_BUILD</name>
            <member>
                <project>LibEdsp</project>
                <configuration>Library</configuration>
            </member>
            <member>
                <project>TestEdsp</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
